// Arduino Mega 


/*
 * PARTS: 
 * 3 x Servo 
 * 
 * 8 x IR Sensor ( 2 gallon - 3 bote - 3 sachet ) 
 * 1 x 5v 20A Power Supply
 * 1 x 4 - channel Relay (barcode1 - barcode2 - barcode3) 
 * 3 x input button (relayRPI1 - relayRPI2 - relayRPI3) 
 * 3x servo
 */

 
//Ir
#define ir1 31 // Sensors sachet
#define ir2 33
#define ir3 35 
#define ir4 39 // Sensors Bote
#define ir5 41 
#define ir6 43 // Sensors Gallon
#define ir7 47 
#define ir8 49
// Barcode
#define botRelay 8
#define galRelay 9
#define sacRelay 7
// Servo


#define servopin1 A2
#define servopin2 A1
#define servopin3 A0


// RPI Trigger Buttons
#define botbuttonPi 3
#define galbuttonPi 4
#define sacbuttonPi 2

#include <Servo.h>
int rpi;
int sdwn = 80;
int sup = 145;
int smid = 125;
int bdwn = 110;
int bup = 200;
int bmid = 150;
int gdwn = 30;
int gup = 100;
int gmid = 50;

int lastButtonState = 1;
boolean sacIR = false;
boolean botIR = false;
boolean galIR = false;
boolean sacBtn;
boolean botBtn;
boolean galBtn;
boolean scanning3 = false;
boolean scanning1 = false;
boolean scanning2 = false;


boolean complete = true;
Servo servo1;
Servo servo2;
Servo servo3;
void setup() {
 Serial.begin(9600);
 pinMode(ir1, INPUT);
 pinMode(ir2, INPUT);
 pinMode(ir3, INPUT);
 pinMode(ir4, INPUT);
 pinMode(ir5, INPUT);
 pinMode(ir6, INPUT);
 pinMode(ir7, INPUT);
  pinMode(ir8, INPUT);
  
 pinMode(botbuttonPi, INPUT_PULLUP);
  pinMode(galbuttonPi, INPUT_PULLUP);
    pinMode(galbuttonPi, INPUT_PULLUP);

  
  pinMode(botRelay, OUTPUT);
  pinMode(galRelay, OUTPUT);
  pinMode(sacRelay, OUTPUT);  

 servo1.attach(servopin1);
 servo2.attach(servopin2);
  servo3.attach(servopin3);

    digitalWrite(botRelay, LOW);
    digitalWrite(galRelay, LOW);
    digitalWrite(sacRelay, LOW);

 delay(2000);
        digitalWrite(botRelay, HIGH);
    digitalWrite(galRelay, HIGH);
    digitalWrite(sacRelay, HIGH);
    delay(1000);
 delay(500);
 servo1.write(smid);
  servo2.write(bmid);
   servo3.write(gmid);
 delay(1000);
 servo1.write(sdwn);
  servo2.write(bdwn);
    servo3.write(gdwn);
 delay(1000);
 servo1.write(smid);
  servo2.write(bmid);
   servo3.write(gmid);
 delay(1000);
    Serial.println("ready");
 delay(5000);
}

void loop() {
if(digitalRead(ir1) == LOW || digitalRead(ir2) == LOW || digitalRead(ir3) == LOW) {
  Serial.println("sachet");
  sacIR = true ;
//  botIR = "";
//  galIR = "" ;
  
//   complete = true;
}

//Serial.print(digitalRead(ir1));
//
//Serial.print(digitalRead(ir2));
//
//Serial.println(digitalRead(ir3));
//
//
//Serial.print(digitalRead(ir4));
//Serial.println(digitalRead(ir5));
//
//Serial.print(digitalRead(ir6));
//Serial.print(digitalRead(ir7));
//Serial.println(digitalRead(ir8));


if(digitalRead(ir4) == LOW || digitalRead(ir5) == LOW) {
 Serial.println("bote");
  botIR = true ;
//  galIR = "" ;
//   sacIR = "" ;
//   complete = true;
} 
if(digitalRead(ir6) == LOW || digitalRead(ir7) == LOW || digitalRead(ir8) == LOW) {
  Serial.println("gallon");
  galIR = true ;
//  botIR = ""; 
//  sacIR = "" ;
  
//   complete = true;
}
  
  if(sacIR == true && complete == true && scanning1 == false){
      
      Serial.println("SACHET DETECTED");  
      digitalWrite(sacRelay, LOW);
      delay(500);
      digitalWrite(sacRelay, HIGH);
      delay(100);   
      scanning1 = true;
 
      delay(6000);
           complete = false;
           
  if(digitalRead(sacbuttonPi) == LOW && scanning1 == true){
    sacBtn = true;
//    scanning1 = false;
  }
  else if(digitalRead(sacbuttonPi) == HIGH && scanning1 == true){
    sacBtn = false;
//    scanning1 = false;
  }
  }

  if(  botIR == true   && complete == true && scanning2 == false){
   
      
      Serial.println("BOTE DETECTED");
      digitalWrite(botRelay, LOW);
      delay(500);
      digitalWrite(botRelay, HIGH);
      delay(100);    
      scanning2 = true;
 
      delay(6000);
           complete = false;
           
  if(digitalRead(botbuttonPi) == LOW && scanning2 == true){
    botBtn = true;
//    scanning2 = false;
  }
  
  else if(digitalRead(botbuttonPi) == HIGH && scanning2 == true){
    botBtn = false;
//    scanning2 = false;
  }
  }

  if(galIR == true  && complete == true && scanning3 == false){
        
      
      Serial.println("GALON DETECTED");
      digitalWrite(galRelay, LOW);
      delay(500);
      digitalWrite(galRelay, HIGH);
      delay(100);   
      scanning3 = true;
//      complete = false;
      delay(6000);
       complete = false;
       if(digitalRead(galbuttonPi) == LOW && scanning3 == true){
    galBtn = true;
//    scanning3 = false;
  }
  else if(digitalRead(galbuttonPi) == HIGH && scanning3 == true){
    galBtn = false;
//    scanning3 = false;
  }
  }



   


  if(sacBtn == true && complete == false && scanning1 == true){
    
      Serial.println("SACHET good ");
  servo1.write(sup);
  delay(1000);
  servo1.write(smid);
  delay(1000);
  complete = true;
    sacBtn = false;
  sacIR = false;
  scanning1 = false;
  }
  if(sacBtn == false && complete == false && scanning1 == true){
  
      Serial.println("SACHET bad");
  servo1.write(sdwn);
  delay(1000);
  servo1.write(smid);
  delay(1000);
    scanning1 = false;
    complete = true;
    sacIR = false;
  }
    if(botBtn == true && complete == false && scanning2 == true){
      
      Serial.println("BOTE good");
  servo2.write(bup);
  delay(1000);
  servo2.write(bmid);
  delay(1000);
  complete = true;
    botBtn = false;
  botIR = false;
  scanning2 = false;
  }
  if(botBtn == false && complete == false && scanning2 == true){
    
      Serial.println("BOTE bad");
  servo2.write(bdwn);
  delay(1000);
  servo2.write(bmid);
  delay(1000);
    scanning2 = false;
    complete = true;
    botIR = false;
     botBtn = false;
  }
    if(galBtn == true && complete == false  && scanning3 == true){

      Serial.println("GALON good");
  servo3.write(gup);
  delay(1000);
  servo3.write(gmid);
  delay(1000);
  complete = true;
  galBtn = false;
  galIR = false;
  scanning3 = false;
  }
  if(galBtn == false && complete == false && scanning3 == true){
  
      Serial.println("GALON bad");
  servo3.write(gdwn);
  delay(1000);
  servo3.write(gmid);
  delay(1000);
    scanning3 = false;
    complete = true;
    galIR = false;
  }

    delay(50);
}
